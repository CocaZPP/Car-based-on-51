# Keil uVision project car.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: stepmot.h config.h timedly.h ultradtc.h lcd1602.h linedtc.h main.c IOCfg.c stepmot.c timedly.c ultradtc.c lcd1602.c linedtc.c ds1302.c
